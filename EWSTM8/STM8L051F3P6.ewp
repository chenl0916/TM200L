# IAR project STM8L051F3P6.ewp, settings and files
configuration STM8L051F3P6 (STM8, debug)
  General.GenDeviceSelectMenu: STM8L151F3 STM8L151F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x200
  General.GenHeapSize: 0x000
  ICCSTM8.CCDefines: STM8L05X_MD_VL
  ICCSTM8.CCIncludePath2: ..; ..\Drivers\STM8L15x_StdPeriph_Driver\src; ..\Drivers\STM8L15x_StdPeriph_Driver\inc; ..\Inc; ..\Src
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: TM200L_APP.hex
  ILINK.IlinkOutputFile: STM8L051F3P6.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../Src/: adc.c atcmd.c iic.c initialization.c iwdg.c main.c rtc.c stm8l15x_it.c uartdrv.c wwdg.c
    ../Drivers/STM8L15x_StdPeriph_Driver/src/: stm8l15x_rtc.c
  group STM8L15x_StdPeriph_Driver
    ../Drivers/STM8L15x_StdPeriph_Driver/src/: stm8l15x_adc.c stm8l15x_clk.c stm8l15x_dma.c stm8l15x_exti.c stm8l15x_gpio.c stm8l15x_i2c.c stm8l15x_itc.c stm8l15x_iwdg.c stm8l15x_pwr.c stm8l15x_rst.c stm8l15x_syscfg.c stm8l15x_tim3.c stm8l15x_usart.c stm8l15x_wwdg.c
