<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>STM8L051F3P6</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <group>
    <name>Application</name>
    <file>
      <name>$PROJ_DIR$\..\Src\adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Src\atcmd.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Src\iic.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Src\initialization.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Src\iwdg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Src\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Src\rtc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Src\stm8l15x_it.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Drivers\STM8L15x_StdPeriph_Driver\src\stm8l15x_rtc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Src\uartdrv.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Src\wwdg.c</name>
    </file>
  </group>
  <group>
    <name>STM8L15x_StdPeriph_Driver</name>
    <file>
      <name>$PROJ_DIR$\..\Drivers\STM8L15x_StdPeriph_Driver\src\stm8l15x_adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Drivers\STM8L15x_StdPeriph_Driver\src\stm8l15x_clk.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Drivers\STM8L15x_StdPeriph_Driver\src\stm8l15x_dma.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Drivers\STM8L15x_StdPeriph_Driver\src\stm8l15x_exti.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Drivers\STM8L15x_StdPeriph_Driver\src\stm8l15x_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Drivers\STM8L15x_StdPeriph_Driver\src\stm8l15x_i2c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Drivers\STM8L15x_StdPeriph_Driver\src\stm8l15x_itc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Drivers\STM8L15x_StdPeriph_Driver\src\stm8l15x_iwdg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Drivers\STM8L15x_StdPeriph_Driver\src\stm8l15x_pwr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Drivers\STM8L15x_StdPeriph_Driver\src\stm8l15x_rst.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Drivers\STM8L15x_StdPeriph_Driver\src\stm8l15x_syscfg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Drivers\STM8L15x_StdPeriph_Driver\src\stm8l15x_tim3.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Drivers\STM8L15x_StdPeriph_Driver\src\stm8l15x_usart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Drivers\STM8L15x_StdPeriph_Driver\src\stm8l15x_wwdg.c</name>
    </file>
  </group>
</project>


